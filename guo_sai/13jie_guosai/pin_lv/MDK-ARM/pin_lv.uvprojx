# Keil uVision project pin_lv.uvprojx, settings and files
target pin_lv (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: pin_lv +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;        ../Drivers/STM32G4xx_HAL_Driver/Inc;        ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;        ../Drivers/CMSIS/Include;        ..\App;        ..\App\Eeprom;        ..\App\IIC;        ..\App\Key;        ..\App\LCD;        ..\App\LED;        ..\App\ADC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group App/Module
    ../App/Eeprom/: eeprom.c
    ../App/IIC/: i2c - hal.c
    ../App/LCD/: lcd.c
    ../App/LED/: led.c
    ../App/Key/: key.c
    ../App/ADC/: myadc.c
  group App/Config
    ../App/: config.c interrupt.c
software components: CMSIS:CORE 4.3.0
